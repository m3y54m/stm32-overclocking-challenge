# file: config.ioc
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Mcu.Family=STM32F1
Mcu.Name=STM32F103C(8-B)Tx
Mcu.Package=LQFP48
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PC14-OSC32_IN.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PC14-OSC32_IN.Signal=EVENTOUT
PD0-OSC_IN.Mode=HSE-External-Oscillator
PD0-OSC_IN.Signal=RCC_OSC_IN
PD1-OSC_OUT.Mode=HSE-External-Oscillator
PD1-OSC_OUT.Signal=RCC_OSC_OUT
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=Makefile
RCC.AHBFreq_Value=144000000
RCC.APB1Freq_Value=144000000
RCC.APB1TimFreq_Value=144000000
RCC.APB2Freq_Value=144000000
RCC.APB2TimFreq_Value=144000000
RCC.HCLKFreq_Value=144000000
RCC.HSE_VALUE=16000000
RCC.PLLMUL=RCC_PLL_MUL9
RCC.PLLSourceVirtual=RCC_PLLSOURCE_HSE
RCC.RCC_MCOSource=RCC_MCO1SOURCE_PLLCLK
RCC.SYSCLKFreq_VALUE=144000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
RCC.USBFreq_Value=144000000
board=custom

// file: Src/main.c
/* USER CODE BEGIN Header */
/**
 ******************************************************************************
 * @file           : main.c
 * @brief          : Main program body
 ******************************************************************************
 * @attention
 *
 * Copyright (c) 2023 STMicroelectronics.
 * All rights reserved.
 *
 * This software is licensed under terms that can be found in the LICENSE file
 * in the root directory of this software component.
 * If no LICENSE file comes with this software, it is provided AS-IS.
 *
 ******************************************************************************
 */
/* USER CODE END Header */
#include "main.h"

void SystemClock_Config(void);
static void MX_GPIO_Init(void);

/* USER CODE BEGIN 0 */
inline void init_v1_v2(void)
{
  // Load required values in registers using assembly instructions
  asm volatile(
      "ldr r0, =0x4001100C\n" // Load GPIOC_ODR address into register r0
      "ldr r1, [r0]\n"        // Load value in the GPIOC_ODR address into register r1
      "ldr r2, =0x00004000\n" // Move the value of bit mask for PC14 into register r2
  );
}

inline void toggle_v1(void)
{
  // Toggle PC14 using assembly instructions
  asm volatile(
      "eor r1, r2\n"   // XOR the last value of GPIOC_ODR (r1) with the mask (r2)
      "str r1, [r0]\n" // Store the new value (r1) back to the address of GPIOC_ODR
  );
}

inline void toggle_v2(void)
{
  // Toggle PC14 using assembly instructions
  asm volatile(
      "eors r1, r2\n"  // XOR the last value of GPIOC_ODR (r1) with the mask (r2)
      "str r1, [r0]\n" // Store the new value (r1) back to the address of GPIOC_ODR
  );
}

inline void init_v3(void)
{
  // Load required values in registers using assembly instructions
  asm volatile(
      "ldr r0, =0x4001100C\n" // Load GPIOC_ODR address into register r0
      "ldr r1, =0x00000000\n" // Move the value for PC14 = 0 into register r1
      "ldr r2, =0x00004000\n" // Move the value for PC14 = 1 into register r2
  );
}

inline void toggle_v3(void)
{
  // Toggle PC14 using assembly instructions
  asm volatile(
      "str r2, [r0]\n" // Store value of r2 (PC14 = 1) to the address of GPIOC_ODR
      "str r1, [r0]\n" // Store value of r1 (PC14 = 0) to the address of GPIOC_ODR
  );
}

inline void toggle_v4(void)
{
  // Toggle PC14 using EVENTOUT function
  asm volatile(
      "sev\n" // Set EVENTOUT pin (PC14) for one clock cycle (and then reset it) => PC14 = 1
      "nop\n" // Wait for one clock cycle and do nothing (while EVENTOUT is reset) => PC14 = 0
      "sev\n"
      "nop\n"
      "sev\n"
      "nop\n"
      "sev\n"
      "nop\n"
      "sev\n"
      "nop\n"
      "sev\n"
      "nop\n");
}

// Put the toggle_v5() function in SRAM
__attribute__((section(".data"))) inline void toggle_v5(void)
{
  // Toggle PC14 using EVENTOUT function
  asm volatile(
      "sev\n" // Set EVENTOUT pin (PC14) for one clock cycle (and then reset it) => PC14 = 1
      "nop\n" // Wait for one clock cycle and do nothing (while EVENTOUT is reset) => PC14 = 0
  );
}
/* USER CODE END 0 */

int main(void)
{

  /* MCU Configuration--------------------------------------------------------*/

  /* Reset of all peripherals, Initializes the Flash interface and the Systick. */
  HAL_Init();

  /* Configure the system clock */
  SystemClock_Config();

  /* Initialize all configured peripherals */
  MX_GPIO_Init();

  /* Infinite loop */
  /* USER CODE BEGIN WHILE */

  // Frequency of the square wave generated on PC14 using toggle_v1():
  // With HSE = 8MHz :
  // - RCC_PLL_MUL9 => f_HCLK = 72 MHz => f_PC14 = 5.15 MHz (stable)
  // - RCC_PLL_MUL10 => f_HCLK = 80 MHz => f_PC14 = 5.75 MHz (stable)
  // - RCC_PLL_MUL11 => f_HCLK = 88 MHz => f_PC14 = 6.25 MHz (stable)
  // - RCC_PLL_MUL12 => f_HCLK = 96 MHz => f_PC14 = 6.85 MHz (stable)
  // - RCC_PLL_MUL13 => f_HCLK = 104 MHz => f_PC14 = 7.4 MHz (stable)
  // - RCC_PLL_MUL14 => f_HCLK = 112 MHz => f_PC14 = 8.0 MHz (stable)
  // - RCC_PLL_MUL15 => f_HCLK = 120 MHz => f_PC14 = 8.5 MHz (stable)
  // - RCC_PLL_MUL16 => f_HCLK = 128 MHz => f_PC14 = 9.1 MHz (stable)
  // With HSE = 16MHz :
  // - RCC_PLL_MUL9 => f_HCLK = 144 MHz => f_PC14 = 10.3 MHz (stable) => MAXIMUM STABLE FREQUENCY
  // - RCC_PLL_MUL10 => f_HCLK = 160 MHz => f_PC14 = 11.5 MHz (unstable: stops about 20 seconds after startup)

  // Frequency of the square wave generated on PC14 using toggle_v2():
  // With HSE = 8MHz :
  // - RCC_PLL_MUL16 => f_HCLK = 128 MHz => f_PC14 = 10.6 MHz (stable)
  // With HSE = 16MHz :
  // - RCC_PLL_MUL9 => f_HCLK = 144 MHz => f_PC14 = 12.0 MHz (stable) => MAXIMUM STABLE FREQUENCY
  // - RCC_PLL_MUL10 => f_HCLK = 160 MHz => f_PC14 = 13.3 MHz (unstable: stops about 20 seconds after startup)

  // Frequency of the square wave generated on PC14 using a single toggle_v3():
  // With HSE = 8MHz :
  // - RCC_PLL_MUL16 => f_HCLK = 128 MHz => f_PC14 = not tested but expected to be about 18 MHz
  // With HSE = 16MHz :
  // - RCC_PLL_MUL9 => f_HCLK = 144 MHz => f_PC14 = 20.5 MHz (stable) => MAXIMUM STABLE FREQUENCY
  // - RCC_PLL_MUL10 => f_HCLK = 160 MHz => f_PC14 = 22.9 MHz (unstable: stops about 20 seconds after startup)

  // Frequency of the square wave generated on PC14 using multiple consecutive toggle_v3()'s:
  // With HSE = 8MHz :
  // - RCC_PLL_MUL16 => f_HCLK = 128 MHz => f_PC14 = not tested but expected to be about 32.78 MHz
  // With HSE = 16MHz :
  // - RCC_PLL_MUL9 => f_HCLK = 144 MHz => f_PC14 = 36.2 MHz (stable) => MAXIMUM STABLE FREQUENCY
  // - RCC_PLL_MUL10 => f_HCLK = 160 MHz => f_PC14 = 40 MHz (unstable: stops in less than 1 second after startup)

  // Frequency of the square wave generated on PC14 using multiple consecutive toggle_v4()'s:
  // With HSE = 8MHz :
  // - RCC_PLL_MUL16 => f_HCLK = 128 MHz => f_PC14 = 64.10 MHz (stable)
  // With HSE = 16MHz :
  // - RCC_PLL_MUL8 => f_HCLK = 128 MHz => f_PC14 = 64.10 MHz (stable)
  // - RCC_PLL_MUL9 => f_HCLK = 144 MHz => f_PC14 = 72.46 MHz (stable) => MAXIMUM STABLE FREQUENCY

  // Frequency of the square wave generated on PC14 using multiple consecutive toggle_v5()'s:
  // With HSE = 16MHz :
  // - RCC_PLL_MUL8 => f_HCLK = 128 MHz => f_PC14 = 64.10 MHz (stable)
  // - RCC_PLL_MUL9 => f_HCLK = 144 MHz => f_PC14 = 72.46 MHz (stable)
  // - RCC_PLL_MUL10 => f_HCLK = 160 MHz => f_PC14 = 80.00 MHz (stable) => MAXIMUM STABLE FREQUENCY

  while (1)
  {
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    toggle_v5();
    /* USER CODE END WHILE */

  }
}

void SystemClock_Config(void)
{
  RCC_OscInitTypeDef RCC_OscInitStruct = {0};
  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

  /** Initializes the RCC Oscillators according to the specified parameters
  * in the RCC_OscInitTypeDef structure.
  */
  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSE;
  RCC_OscInitStruct.HSEState = RCC_HSE_ON;
  RCC_OscInitStruct.HSEPredivValue = RCC_HSE_PREDIV_DIV1;
  RCC_OscInitStruct.HSIState = RCC_HSI_ON;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_ON;
  RCC_OscInitStruct.PLL.PLLSource = RCC_PLLSOURCE_HSE;
  RCC_OscInitStruct.PLL.PLLMUL = RCC_PLL_MUL10;
  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    Error_Handler();
  }

  /** Initializes the CPU, AHB and APB buses clocks
  */
  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
                              |RCC_CLOCKTYPE_PCLK1|RCC_CLOCKTYPE_PCLK2;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV1;
  RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV1;

  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_2) != HAL_OK)
  {
    Error_Handler();
  }
}

static void MX_GPIO_Init(void)
{
  GPIO_InitTypeDef GPIO_InitStruct = {0};

  /* GPIO Ports Clock Enable */
  __HAL_RCC_GPIOC_CLK_ENABLE();
  __HAL_RCC_GPIOD_CLK_ENABLE();
  __HAL_RCC_GPIOA_CLK_ENABLE();

  /*Configure GPIO pin : PC14 */
  GPIO_InitStruct.Pin = GPIO_PIN_14;
  GPIO_InitStruct.Mode = GPIO_MODE_AF_PP;
  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_HIGH;
  HAL_GPIO_Init(GPIOC, &GPIO_InitStruct);

  /*Configures the port and pin on which the EVENTOUT Cortex signal will be connected */
  HAL_GPIOEx_ConfigEventout(AFIO_EVENTOUT_PORT_C, AFIO_EVENTOUT_PIN_14);

  /*Enables the Event Output */
  HAL_GPIOEx_EnableEventout();

}

void Error_Handler(void)
{
  __disable_irq();
  while (1)
  {
  }
}
